# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32L151RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\app;.\bsp\inc;.\cmsis;.\library\inc;.\ucosiii\uC-CPU\Cfg;.\ucosiii\uC-CPU\Ports;.\ucosiii\uC-CPU\Source;.\ucosiii\uC-LIB\Cfg;.\ucosiii\uC-LIB\Ports;.\ucosiii\uC-LIB\Source;.\ucosiii\uCOS-III\Cfg;.\ucosiii\uCOS-III\Ports;.\ucosiii\uCOS-III\Source;.\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: app.c app.h main.c fun.c static_init.c
  group BSP
    ./bsp/: bsp.c bsp.h
    ./bsp/src/: cat24c516.c Check_Water.c delay.c ds18b20.c NRF24L01.c RTC.c W_P_Sensor.c power.c
  group CONFIG
    ./ucosiii/uCOS-III/Cfg/: os_cfg.h os_cfg_app.h
    ./ucosiii/uC-LIB/Cfg/: lib_cfg.h
    ./ucosiii/uC-CPU/Cfg/: cpu_cfg.h
    ./bsp/: bsp_cfg.h
    ./app/: app_cfg.h
  group HOOKS
    ./ucosiii/uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h
  group BOOT
    ./boot/: startup_stm32l1xx_md.s
  group CMSIS
    ./cmsis/: system_stm32l1xx.c
  group uc/CPU
    ./ucosiii/uC-CPU/Source/: cpu_core.c
    ./ucosiii/uC-CPU/Ports/: cpu_c.c cpu_a.s
  group uc/LIB
    ./ucosiii/uC-LIB/Source/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uc/PORT
    ./ucosiii/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uc/SOURCE
    ./ucosiii/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group LIBRARY
    ./library/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
